# IAR project USB_STM8_HSI.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: User\Inc; USB\Inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_STM8_HSI.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Linker\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Linker
    Linker/: lnkstm8s003f3.icf
  group USB
    USB/Src/: remove_bit_stuffed.s usb.c usb_process.s usb_received.s usb_rx.s usb_tx.s
  group User
    User/Src/: delay.c main.c
